Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 6b1eb16f-a2b5-4f14-b6b2-d6b3dafa441d, NumberOfSaves: 37]
File name: Project Number
Time: 2024-05-17T11:11:05+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, InPort_2232914_1
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: NLRS_57_AIR_UN_ceiling-diffuser-rtsv_LT_sacs:200, NLRS_57_AIR_UN_ceiling-diffuser-rtsv_LT_sacs:200:2232914
In: Default
Type - Description: Supply grill with valve for use in ceiling, Type RTSVMO and RTSVKO; PredefinedType: DIFFUSER; Material: RAL9010
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_ceiling-diffuser-rtsv_LT_sacs; SACS_Base_Index: 5
Type - Constraints - Default Elevation: 0 mm
Type - General - SACS_Article_Data: RTSV_Data; SACS_Factors: RTSV_Factors; SACS_Revised_by: J. Feeke; SACS_Revision_Date: 17-05-2024; SACS_Revision_Number: 3.21.04
Type - Identity Data - Assembly Code: 57.00; Description: Supply grill with valve for use in ceiling, Type RTSVMO and RTSVKO; Manufacturer: Solid Air Climate Solutions; Model: RTSVMO/RTSVKO; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 17-05-2024; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.21.04; NLRS_C_description: Supply grill with valve for use in ceiling, Type RTSVMO and RTSVKO; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles; Type Name: 200; URL: https://solid-air.nl/producten/solid-air-plafondroosters-rrsv/
Type - Mechanical - Flow - Max Flow: 150 dm3/s; Min Flow: 60 dm3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Classification: 57.00 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: 200; sets with these values: 2
Other - Family: NLRS_57_AIR_UN_ceiling-diffuser-rtsv_LT_sacs; Family and Type: NLRS_57_AIR_UN_ceiling-diffuser-rtsv_LT_sacs: 200; Type: 200; Type Id: 2232902
Model Properties - Conus max setting: 20; Conus min setting: -2; Conus Setting: 20; SACS_Color_Ral: yes; SACS_Mounting_Ring: no; SACS_Option_1: RTSVKO; SACS_Standard_Color: yes
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - NLRS_M_c01_diameter: 200 mm; Volume: 0.0000811777 m3
Identity Data - Mark: 8695; NLRS_C_materiaal_kleur: RAL 9010; NLRS_C_model: RTSVKO 200; SACS_Article_Code: 8250000027; SACS_Gross_Cost: 27; SACS_Price_Date: 24-04-2024
Materials and Finishes - SACS_Color: RAL 9010; SACS_Face_Color: RAL9010
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Max_Lp_dBA: 28; SACS_Max_Ploss: 35 Pa; SACS_Primairy_Air_Temperature: 15 C; SACS_Room_Temperature: 25 C; System Classification: Supply Air
Mechanical - Flow - Flow: 0 dm3/s; NLRS_M_c01_debiet: 0 dm3/s; SACS_Cooling_Capacity: 0 W; SACS_Heating_Capacity: 0 W; SACS_Lp_dBA: 0; SACS_Throw: 0 mm
Phasing - Phase Created: New Construction
Visibility - SACS_Arrows_and_Throw_Enabled: yes; SACS_Show_Throw: yes; SACS_Warning_Disable: no
